# Repository rayho6240-arch/RocketCup-avionic-board-project (continued)

## KiCad design hardware/small_avionic/Joyce2/SmallAvionic.kicad_pcb

Parts:
3V1: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
BU101: FanPinHeader_1x03_P2.54mm_Vertical
BZ1: Active Buzzer; Buzzer_15x7.5RM7.6
Buck_5v1: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
C1, C31: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3, C4, C6, C8, C11, C13, C18, C24, C26, C27, C28, C29, C30, C33: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C16, C17: 47u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C20, C23, C32, C104: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C21, C22: 22pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C25: 4.7u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C101: 330u; CP_Radial_D6.3mm_P2.50mm
C102: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C103: 2.2u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: TVS; D_SMA-SMB_Universal_Handsoldering
D2: G_5V; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3: B_3V3; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D4: G; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D5: R; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D6: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
F1: Fuse; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
FB1: FerriteBead 120R @ 100M; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
GND1: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2
J1: Conn_01x02; Molex_Micro-Fit_3.0_43650-0221_1x02_P3.00mm_Vertical
J2: Boot_mode_pin; PinSocket_1x02_P2.00mm_Vertical
J3: Conn_01x04; PinSocket_1x04_P2.00mm_Vertical
J4: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HCTL_HC-TYPE-C-16P-01A
J5, J8: Conn_01x03; JST_GH_BM03B-GHS-TBT_1x03-1MP_P1.25mm_Vertical
J6: Conn_01x04; JST_EH_B4B-EH-A_1x04_P2.50mm_Vertical
J7: Screw_Terminal_01x01; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
J9: Conn_01x02; JST_EH_B2B-EH-A_1x02_P2.50mm_Vertical
L101, L102: 1mH; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
Q1, Q2: TSM3481CX6 RFG; SOT-23
Q3: NMOS; TO-252-2
R1, R2, R20, R21, R22, R26, R27, R29, R30, R32: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R5, R9: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7: 1M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10: 0 ohm; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R13, R14: 22ohm; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15, R16, R28: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R17: 1.5k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R18, R19: 5.1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R23, R31: 2.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R24, R25: 2.2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R40: 5k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_Push; SW_Push_1P1T_NO_E-Switch_TL3301NxxxxxG
SW2: USER_Buttom; SW_Push_1P1T_NO_E-Switch_TL3301NxxxxxG
U1: LD1117S33TR_SOT223; SOT-223-3_TabPin2
U2: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U3: LTC4412xS6; TSOT-23-6
U5: MMC5983MA; MMC5983MA_MEM
U6: BMP390; 10LGA_2X2X0p75_BOS
U7: W25Q128JVS; SOIC-8_5.3x5.3mm_P1.27mm
U8: BMI088; Bosch_LGA-16_4.5x3mm_P0.5mm_LayoutBorder7x1y_ClockwisePinNu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
V_BAT+1: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
Y1: 8Mhz; Crystal_SMD_0603-4Pin_6.0x3.5mm_HandSoldering

Connections:
+3.3V: 3V1.1, C1.1, C2.1, C3.1, C8.1, C11.1, C13.1, C16.1, C17.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C32.1, FB1.2, J2.1, J3.1, J6.3, R9.1, R16.2, R17.2, R20.2, R21.2, R22.2, R23.1, R26.2, R27.2, R30.1, R31.1, U1.2 (VO), U2.1 (VBAT), U2.24 (VDD), U2.36 (VDD), U2.48 (VDD), U5.2 (VDD), U5.4 (SPI_CS), U5.13 (VDDIO), U6.1 (VDDIO), U6.10 (VDD), U7.8 (VCC), U8.3 (VDD), U8.11 (VDDIO)
+USB_5V: J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS), Q2.3 (D), R5.2, U3.6 (SENSE)
BOOT0: J2.2, R2.1, U2.44 (BOOT0)
BOOT1: R1.1, U2.20 (PB2)
BUCK_5V: BU101.3 (VOUT), Buck_5v1.1, C6.1, C102.1, Q2.2 (S), R15.2, U1.3 (VI), U3.1 (VIN)
Battery_Sensing: C33.1, R32.1, R40.2, U2.19 (PB1)
Buzzer: R28.2, U2.22 (PB11)
CSB_Accel: R27.1, U2.14 (PA4), U8.14 (~CSB1)
CSB_Baro: R30.2, U2.18 (PB0), U6.6 (CSB)
CSB_Flash: R26.1, U2.29 (PA8), U7.1 (~CS)
CSB_Gyro: R22.1, U2.13 (PA3), U8.5 (~CSB2)
FIRE: J5.2, U2.45 (PB8)
GND: BU101.2 (GND), C1.2, C2.2, C3.2, C4.2, C6.2, C8.2, C11.2, C13.2, C16.2, C17.2, C18.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C102.2, C104.2, D1.1 (A1), D2.1 (K), D3.1 (K), GND1.1, J1.2, J3.4, J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J4.S1 (SHIELD), J5.3, J6.4, J7.1, J8.3, L102.2, Q3.3 (S), R1.2, R2.2, R3.2, R7.2, R18.2, R19.2, R24.1, R25.1, R29.2, R40.1, SW1.1, SW2.1, U1.1 (GND), U2.8 (VSSA), U2.23 (VSS), U2.35 (VSS), U2.47 (VSS), U3.2 (GND), U5.9 (GND), U5.11 (GND), U6.3 (VSS), U6.8 (VSS), U6.9 (VSS), U7.4 (GND), U8.2 (GNDA), U8.4 (GNDA), U8.6 (GNDIO), U8.7 (PS), Y1.2 (G), Y1.4 (G)
HSE_IN: C21.1, U2.5 (PD0), Y1.1
HSE_OUT: R10.1, U2.6 (PD1), Y1.3
I2C1_SCL: J6.1, R23.2, U2.42 (PB6), U5.1 (SCL/SPI_SCK)
I2C1_SDA: J6.2, R31.2, U2.43 (PB7), U5.16 (SDA/SPI_SDI)
INT_Accel1: U2.10 (PA0), U8.16 (INT1)
INT_Accel2: U2.11 (PA1), U8.1 (INT2)
INT_Baro: U2.21 (PB10), U6.7 (INT)
INT_Gyro: U2.12 (PA2), U8.12 (INT3)
INT_Magn: U2.41 (PB5), U5.15 (INT)
LED_SYS: D4.2 (A), U2.2 (PC13)
LED_State: D5.2 (A), U2.3 (PC14)
NRST: C4.1, SW1.2, U2.7 (NRST)
unnamed: BU101.1 (VIN), C104.1, L101.2
unnamed: BZ1.2 (-), D6.2 (A), Q3.1 (D)
unnamed: C22.1, R10.2
unnamed: C101.2, C103.2, L102.1
unnamed: D1.2 (A2), F1.2, J9.2, Q1.3 (D)
unnamed: D2.2 (A), R15.1
unnamed: D3.2 (A), R16.1
unnamed: D4.1 (K), R24.2
unnamed: D5.1 (K), R25.2
unnamed: F1.1, J1.1
unnamed: J4.A5 (CC1), R18.1
unnamed: J4.B5 (CC2), R19.1
unnamed: J4.A6 (D+), J4.B6 (D+), R14.2
unnamed: J4.A7 (D-), J4.B7 (D-), R13.1
unnamed: Q1.1 (G), R3.1
unnamed: Q2.1 (G), U3.5 (GATE)
unnamed: Q3.2 (G), R28.1, R29.1
unnamed: C18.1, C20.1, FB1.1, U2.9 (VDDA)
unnamed: R5.1, R7.1, U3.3 (CTL)
unnamed: C31.1, U5.10 (CAP)
unnamed: R20.1, U7.7 (~HOLD/~RESET/IO_{3})
PWM Servo: J5.1, U2.46 (PB9)
SPI1_MISO: U2.16 (PA6), U6.5 (SDO), U8.10 (SDO2), U8.15 (SDO1)
SPI1_MOSI: U2.17 (PA7), U6.4 (SDI), U8.9 (SDI/SDA)
SPI1_SCK: U2.15 (PA5), U6.2 (SCK), U8.8 (SCK/SCL)
SPI2_MISO: U2.27 (PB14), U7.2 (DO/IO_{1})
SPI2_MOSI: U2.28 (PB15), U7.5 (DI/IO_{0})
SPI2_SCK: U2.26 (PB13), U7.6 (CLK)
SUP_STAT: R9.2, U2.40 (PB4), U3.4 (STAT)
SWCLK: J3.3, U2.37 (PA14)
SWDIO: J3.2, U2.34 (PA13)
USART1_RX: J8.2, U2.31 (PA10)
USART1_TX: J8.1, U2.30 (PA9)
USB_D+: R14.1, R17.1, U2.33 (PA12)
USB_D-: R13.2, U2.32 (PA11)
USER_BT: C30.1, SW2.2, U2.4 (PC15)
V_BAT+: BZ1.1 (+), C101.1, C103.1, D6.1 (K), J9.1, L101.1, Q1.2 (S), R32.2, V_BAT+1.1
WP_Flash: R21.1, U2.25 (PB12), U7.3 (~WP/IO_{2})

Notes on the sheet:
C33濾波
Power
C32濾波
讓大小航電板共地
用USB供電 &防止電池電流倒灌到USB
common ground to Main_AV GND
decoupling
UART communication
V=BAT(8.4)*5/(5+10)=2.8V
Battery monitor
Flash
決定開機後要正常執行or重灌
3.3V是用於open-drain，並非電源輸出
Buck
把5V再轉為3.3V給mcu跟感測器用
Indicator
C4去彈跳電容， 吸收雜訊
clock
Connection to Main_AV
狀態輸出腳位
External reset
C30濾波
IMU
Buttom
PB12 GPIO_OUT
C27在VCC旁邊 C25在3.3V旁
磁珠:抑制高頻雜訊
LDO
SDA、SCL要上拉
maybe a remove before flight?
47uF(tantalum capacitor
C26C29要記得放在VDD、VDDIO旁邊
Serial Wire Debug
C21C22負載電容， 負責與石英晶體共振
buck_5V再接到LDO
Remove Before Flight
CSB上拉
防反向突波
Ignition connector
Boot&Debug

Board: 4 copper layers, 76.8 x 61.5 mm, 99 parts (0 on the bottom side), 63 nets.

## Code that names these connections

File Main_Code/bigav_407.ioc (part):

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Mcu.Name=STM32F407V(E-G)Tx
Mcu.Package=LQFP100
Mcu.UserName=STM32F407VGTx
PA0-WKUP.Signal=S_TIM2_CH1_ETR
PA1.GPIOParameters=GPIO_PuPd,GPIO_Label
PA1.GPIO_Label=USER_BT1
PA1.GPIO_PuPd=GPIO_PULLUP
PA1.Signal=GPIO_Input
PA11.Mode=Device_Only
PA11.Signal=USB_OTG_FS_DM
PA12.Mode=Device_Only
PA12.Signal=USB_OTG_FS_DP
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_Speed,PinState,GPIO_Label
PA15.GPIO_Label=FLASH_CSB
PA15.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA15.PinState=GPIO_PIN_SET
PA15.Signal=GPIO_Output
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA4.GPIOParameters=GPIO_Speed,PinState,GPIO_PuPd,GPIO_Label
PA4.GPIO_Label=CSB_BARO
PA4.GPIO_PuPd=GPIO_PULLUP
PA4.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA4.PinState=GPIO_PIN_SET
PA4.Signal=GPIO_Output
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA6.Mode=Full_Duplex_Master
PA6.Signal=SPI1_MISO
PA7.Mode=Full_Duplex_Master
PA7.Signal=SPI1_MOSI
PA8.GPIOParameters=PinState,GPIO_Label
PA8.GPIO_Label=RST_GPS
PA8.PinState=GPIO_PIN_SET
PA8.Signal=GPIO_Output
PA9.Mode=Activate_VBUS
PA9.Signal=USB_OTG_FS_VBUS
PB0.GPIOParameters=GPIO_PuPd,GPIO_Label
PB0.GPIO_Label=INT_HIGHG1
PB0.GPIO_PuPd=GPIO_PULLDOWN
PB0.Signal=GPXTI0
PB1.GPIOParameters=GPIO_PuPd,GPIO_Label
PB1.GPIO_Label=INT_BARO
PB1.GPIO_PuPd=GPIO_PULLDOWN
PB1.Signal=GPXTI1
PB10.Mode=Full_Duplex_Master
PB10.Signal=SPI2_SCK
PB11.GPIOParameters=GPIO_Speed,PinState,GPIO_PuPd,GPIO_Label
PB11.GPIO_Label=CSB_GYRO
PB11.GPIO_PuPd=GPIO_PULLUP
PB11.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PB11.PinState=GPIO_PIN_SET
PB11.Signal=GPIO_Output
PB12.GPIOParameters=GPIO_Speed,PinState,GPIO_PuPd,GPIO_Label
PB12.GPIO_Label=CSB_ACCEL
PB12.GPIO_PuPd=GPIO_PULLUP
PB12.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PB12.PinState=GPIO_PIN_SET
PB12.Signal=GPIO_Output
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB3.Mode=Full_Duplex_Master
PB3.Signal=SPI3_SCK
PB4.Mode=Full_Duplex_Master
PB4.Signal=SPI3_MISO
PB5.Mode=Full_Duplex_Master
PB5.Signal=SPI3_MOSI
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PB8.Mode=I2C
PB8.Signal=I2C1_SCL
PC0.GPIOParameters=GPIO_Label
PC0.GPIO_Label=BAT_SENSE
PC0.Signal=ADCx_IN10
PC1.Signal=GPIO_Input
PC10.Mode=SD_4_bits_Wide_bus
PC10.Signal=SDIO_D2
PC11.Mode=SD_4_bits_Wide_bus
PC11.Signal=SDIO_D3
PC12.Mode=SD_4_bits_Wide_bus
PC12.Signal=SDIO_CK
PC3.GPIOParameters=GPIO_PuPd,GPIO_Label
PC3.GPIO_Label=USER_BT2
PC3.GPIO_PuPd=GPIO_PULLUP
PC3.Signal=GPIO_Input
PC4.GPIOParameters=GPIO_Speed,PinState,GPIO_PuPd,GPIO_Label
PC4.GPIO_Label=CSB_HIGHG
PC4.GPIO_PuPd=GPIO_PULLUP
PC4.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PC4.PinState=GPIO_PIN_SET
PC4.Signal=GPIO_Output
PC5.GPIOParameters=GPIO_PuPd,GPIO_Label
PC5.GPIO_Label=INT_HIGHG2
PC5.GPIO_PuPd=GPIO_PULLDOWN
PC5.Signal=GPXTI5
PC6.Mode=Asynchronous
PC6.Signal=USART6_TX
PC7.Mode=Asynchronous
PC7.Signal=USART6_RX
PC8.Mode=SD_4_bits_Wide_bus
PC8.Signal=SDIO_D0
PC9.Mode=SD_4_bits_Wide_bus
PC9.Signal=SDIO_D1
PD10.GPIOParameters=GPIO_PuPd,GPIO_Label
PD10.GPIO_Label=LORA433_M1
PD10.GPIO_PuPd=GPIO_PULLDOWN
PD10.Signal=GPIO_Output
PD11.GPIOParameters=GPIO_PuPd,GPIO_Label
PD11.GPIO_Label=LORA433_M0
PD11.GPIO_PuPd=GPIO_PULLDOWN
PD11.Signal=GPIO_Output
PD12.GPIOParameters=GPIO_Speed,PinState,GPIO_PuPd,GPIO_Label
PD12.GPIO_Label=LORA433_RST
PD12.GPIO_PuPd=GPIO_PULLUP
PD12.GPIO_Speed=GPIO_SPEED_FREQ_LOW
PD12.PinState=GPIO_PIN_SET
PD12.Signal=GPIO_Output
PD13.GPIOParameters=GPIO_Label,GPIO_ModeDefaultOutputPP
PD13.GPIO_Label=FIRE
PD13.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_PP
PD13.Signal=GPIO_Output
PD14.GPIOParameters=GPIO_Label
PD14.GPIO_Label=PWM_Servo
PD14.Signal=S_TIM4_CH3
PD2.Mode=SD_4_bits_Wide_bus
PD2.Signal=SDIO_CMD
PD3.GPIOParameters=GPIO_Label
PD3.GPIO_Label=SDIO_DET
PD3.Signal=GPIO_Input
PD4.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultEXTI
PD4.GPIO_Label=LORA920_INT
PD4.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_RISING
PD4.GPIO_PuPd=GPIO_PULLDOWN
PD4.Signal=GPXTI4
PD5.GPIOParameters=GPIO_Label
PD5.GPIO_Label=LORA920_RST
PD5.Signal=GPIO_Output
PD6.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PD6.GPIO_Label=LORA920_BUSY
PD6.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_RISING_FALLING
PD6.Signal=GPXTI6
PD7.GPIOParameters=PinState,GPIO_Label
PD7.GPIO_Label=CSB_LORA920
PD7.PinState=GPIO_PIN_SET
PD7.Signal=GPIO_Output
PD8.Mode=Asynchronous
PD8.Signal=USART3_TX
PD9.Mode=Asynchronous
PD9.Signal=USART3_RX
PE10.GPIOParameters=GPIO_PuPd,GPIO_Label
PE10.GPIO_Label=INT_GYRO2
PE10.GPIO_PuPd=GPIO_PULLDOWN
PE10.Signal=GPXTI10
PE11.GPIOParameters=GPIO_PuPd,GPIO_Label
PE11.GPIO_Label=LORA433_BUSY
PE11.GPIO_PuPd=GPIO_NOPULL
PE11.Signal=GPIO_Input
PE12.GPIOParameters=GPIO_PuPd,GPIO_Label
PE12.GPIO_Label=INT_MAGN
PE12.GPIO_PuPd=GPIO_PULLDOWN
PE12.Signal=GPXTI12
PE2.GPIOParameters=GPIO_Label
PE2.GPIO_Label=LED_SYS
PE2.Signal=GPIO_Output
PE3.Signal=GPIO_Output
PE4.GPIOParameters=GPIO_Label
PE4.GPIO_Label=LED_STAT2
PE4.Signal=GPIO_Output
PE5.Signal=GPIO_Analog
PE7.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultEXTI
PE7.GPIO_Label=INT_ACCEL1
PE7.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_RISING
PE7.GPIO_PuPd=GPIO_PULLDOWN
PE7.Signal=GPXTI7
PE8.GPIOParameters=GPIO_PuPd,GPIO_Label
PE8.GPIO_Label=INT_ACCEL2
PE8.GPIO_PuPd=GPIO_PULLDOWN
PE8.Signal=GPXTI8
PE9.GPIOParameters=GPIO_PuPd,GPIO_Label
PE9.GPIO_Label=INT_GYRO1
PE9.GPIO_PuPd=GPIO_PULLDOWN
PE9.Signal=GPXTI9
PH0-OSC_IN.Mode=HSE-External-Oscillator
PH0-OSC_IN.Signal=RCC_OSC_IN
PH1-OSC_OUT.Mode=HSE-External-Oscillator
PH1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=16000000
RCC.SYSCLKFreq_VALUE=168000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

File firmware/ground_station_mx/GroundStation_MX.ioc (part):

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Mcu.Name=STM32F103C(8-B)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32F103C8Tx
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=USART1_GPS_RX
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA11.Mode=Device
PA11.Signal=USB_DM
PA12.Mode=Device
PA12.Signal=USB_DP
PA13.Signal=SYS_JTMS-SWDIO
PA14.Signal=SYS_JTCK-SWCLK
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=USART2_LoRa1_TX
PA2.Signal=USART2_TX
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=USART2_LoRa1_RX
PA3.Signal=USART2_RX
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=USART2_LoRa1_AUX
PA4.Signal=GPIO_Output
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA6.Mode=Full_Duplex_Master
PA6.Signal=SPI1_MISO
PA7.Mode=Full_Duplex_Master
PA7.Signal=SPI1_MOSI
PA8.Signal=GPIO_Output
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=USART1_GPS_TX
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=USART2_LoRa1_NRST
PB0.Signal=GPIO_Output
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=USART2_LoRa1_M0
PB1.Signal=GPIO_Output
PB10.GPIOParameters=GPIO_Label
PB10.GPIO_Label=SPI2_SDcard_CS
PB10.Signal=GPIO_Output
PB11.GPIOParameters=GPIO_Label
PB11.GPIO_Label=USART1_GPS_D_SEL
PB11.Signal=GPIO_Output
PB13.GPIOParameters=GPIO_Label
PB13.GPIO_Label=SPI2_SDcard_SCK
PB13.Mode=Full_Duplex_Master
PB13.Signal=SPI2_SCK
PB14.GPIOParameters=GPIO_Label
PB14.GPIO_Label=SPI2_SDcard_MISO
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.GPIOParameters=GPIO_Label
PB15.GPIO_Label=SPI2_SDcard_MOSI
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=USART2_LoRa1_M1
PB3.Signal=GPIO_Output
board=custom

File archive/gpsandmagn_driver/GPSandMagn_driver.ioc (part):

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Mcu.Name=STM32F103C(8-B)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32F103C8Tx
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB11.GPIOParameters=GPIO_Label
PB11.GPIO_Label=GPS_debug
PB11.Signal=GPIO_Output
PB13.GPIOParameters=GPIO_Label
PB13.GPIO_Label=Magn_debug
PB13.Signal=GPIO_Output
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PB8.GPIOParameters=GPIO_Label
PB8.GPIO_Label=INT_Magn
PB8.Signal=GPIO_Output
PB9.GPIOParameters=GPIO_Label
PB9.GPIO_Label=RST_GPS
PB9.Signal=GPIO_Output
PD0-OSC_IN.Mode=HSE-External-Oscillator
PD0-OSC_IN.Signal=RCC_OSC_IN
PD1-OSC_OUT.Mode=HSE-External-Oscillator
PD1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=4000000
RCC.SYSCLKFreq_VALUE=8000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log (part)

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2026-01-14 tide in folder BigAvionic
2026-01-14 create SmallAvionic(training) for every member
2026-01-14 complement
2026-01-16 add gitignore
2026-01-16 adjust folder
2026-01-18 完成基本開機電路
2026-01-19 進度到usb
2026-01-20 Ray finish IMU,BMP, Madnetometer. But just whatever3 7 21 copy from internet
2026-01-22 Joyce push 1/22
2026-01-22 Ray copy finish internet For SMALLAvionic. It might not work success T_T
2026-01-25 1-25
2026-01-26 upadate1/26
2026-02-01 complete small av,parachute board
2026-02-02 finished power of Big AV
2026-02-04 Ray finish Ground Station Schematic
2026-02-04 add little thing to Ground sch
2026-02-05 Ray change GPS pullDown R to pullUp, and lus EXT&RESET
2026-02-05 add little
2026-02-05 finished sensors except gps
2026-02-05 finished GPS
2026-02-06 finish lora
2026-02-06 finish sd
2026-02-06 finish big av v1
2026-02-06 GPS_Ground Revise
2026-02-25 joyce push
2026-02-28 add some package of Deployment board
2026-03-01 some changes on Deployment board pcb
2026-03-01 update Deployment board
2026-03-02 Ray start GroundStation PCB
2026-03-02 add hole to connect wire
2026-03-08 assign package for groundstation
2026-03-09 jpush
2026-03-12 tony
2026-03-12 Ray revise two LoRamodule, need Joyce help for free routing
2026-03-15 finish first layer of big av
2026-03-15 save
2026-03-20 adjust top layer wiring
2026-03-22 test
2026-03-23 jpush deployment board
2026-04-29 deployment board
2026-04-30 Big av slight modification+add libraries folder
2026-05-03 recommit production
2026-05-25 Update BigAvionic design and production files
2026-05-25 Optimize .gitignore and untrack DS_Store
2026-05-25 Add subproject notes (備注.md) and optimize .gitignore
2026-05-25 Update README with new folder structure and subproject notes info
2026-05-25 Update recommended KiCad version to 9.0.7 in README
2026-05-25 Update project progress (進度.md), rename Production_MCU_LORA_2_in_1 to Production_MCU_TOP_2_in_1, and restructure subprojects
2026-05-25 Add Arduino GPS & Magnetometer test code and update project milestones in progress.md
2026-05-25 Expand progress.md with professional testing, safety, and launch milestones
2026-05-25 Create Avionic_bay directory and add mechanical design README
2026-05-25 Add progress timestamp guidelines and timestamp completed milestones in progress.md
2026-05-25 Copy stm32 bigav407.ioc from STM32CubeIDE and update BigAvionic notes
2026-05-25 Migrate entire STM32CubeIDE project to RocketCom as Main_AV_F407 and update .gitignore
2026-05-25 Update hardware specs table to use STM32F407VGT6 and BMP388 due to component shortages, and update development progress
2026-05-25 add cad for cad
2026-05-25 build folder for Magn and GPS test
2026-05-25 fix: rewrite 進度.md with clean UTF-8 to fix garbled text on GitHub
2026-05-25 chore: sync README.md
2026-05-25 docs: record today's milestone of completing STM32CubeMX (.ioc) and NVIC/DMA configurations
2026-05-25 docs: update TodoList to show sample boards returned successfully
2026-05-25 refactor: rename Main_AV_F407 to Main_Code and generate full CubeMX configuration
2026-05-26 feat: add LED_SYS toggling in StartDefaultTask for hardware verification
2026-05-26 feat: 完成 MMC5983MA 驅動 bring-up 與 LED 感測器除錯
    目前 STM32 自製 PCB 的 bring-up 狀態：
    * GPS UART 驅動 bring-up 失敗
    * MMC5983MA 磁力計驅動 bring-up 成功
    * I2C 通訊已驗證成功
    * 已可週期性讀取磁力計 raw data
    * 建立 LED-only 感測器除錯流程
2026-05-26 chore: sync renamed .ioc and launch configurations from local generation
2026-05-26 feat: add BMI088 SPI2 IMU driver and real-time reading task
2026-05-26 feat: add printf serial redirect to USART2 for real-time IMU wave plotting
2026-05-27 feat: stabilize NEO-M9N UART bring-up and LED-only GPS debug flow
    成功完成：
    * NEO-M9N GPS UART bring-up
    * USART1 interrupt receive 驗證
    * LED-only GPS alive debug
    * GPS UART RX path 穩定運作
    目前結果：
2026-05-27 refactor: 模組化 GPS 與 MMC5983MA driver，為未來 F407 移植做準備
    將 GPS 與 MMC5983MA driver 從「能運作的測試碼」整理成「可移植的 HAL-based 模組」。
    目標：
    * 未來可從 STM32F103C8T6 移植到 STM32F407
    * 保持 driver 架構簡潔
    * 建立 raw data pipeline
    * 分離 driver 與 parser
2026-05-28 avionic bay v0
2026-05-30 feat(avionics): implement 7-state FSM, dynamic predictive apogee & main deploy, and boundary-safe hot-restart recovery
2026-06-08 CAD body v6(not finished
2026-06-12 docs: update documentation markdown files and python scripts
2026-06-29 avionic bay
