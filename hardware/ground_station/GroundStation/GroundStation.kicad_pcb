# Repository rayho6240-arch/RocketCup-avionic-board-project

File README.md:

# 🚀 RocketCup Avionic Board Project (成大 ISP 航電組)

歡迎來到成大 ISP 航電組的協作平台！這裡存放了我們為比賽設計的所有電路圖、PCB 檔案以及相關硬體參考資料。

為了方便大家協作、快速找到規格書，我們對專案資料夾進行了全面整合與邏輯分類。請大家開發前務必詳細閱讀以下指南。

---

## 📂 檔案結構說明 (去哪裡找你的檔案與資料？)

我們採用結構化、模組化的資料夾配置。請在您負責的子專案資料夾內開發，並參考對應的規格書：

### 1️⃣ 核心開發專案 (由 Git 進行版本控制)
* **[hardware/big_avionic/](hardware/big_avionic/)**: 大火箭航電主板專區 (內附 `備注.md` 進度檔)。
* **[hardware/deployment_board/](hardware/deployment_board/)**: 降落與開傘部署板專區 (內附 `備注.md` 進度檔)。
* **[hardware/ground_station/](hardware/ground_station/)**: 地面接收站專區 (內附 `備注.md` 進度檔)。
* **[hardware/small_avionic/](hardware/small_avionic/)**: 小火箭航電備份板專區 (包含 Joyce、Ray、Tank、Tony 的開發分支，內附 `備注.md` 進度檔)。
* **[hardware/libraries/](hardware/libraries/)**: 共用的核心 KiCad 零件庫 (Symbol & Footprint)。

> 📌 **開發小筆記**：每個開發資料夾下都有一個 **`備注.md`**。請在裡面記錄您的設計要點、遇到的 Bug，並隨著開發勾選進度 Checkbox，讓其他組員知道目前的開發狀況！

### 2️⃣ 整理後的硬體參考資料 (建議在本地參考，不頻繁變動)
* **[Datasheets/](Datasheets/)**: 收納了 13 個重命名後的 PDF 規格書與硬體指南，標註了晶片型號與硬體用途（如：`ADXL375_High_G_Accelerometer_Datasheet.pdf`），一目了然！
* **[hardware/libraries/](hardware/libraries/)**: 收納了參考用的 KiCad 零件庫壓縮檔與解壓資料夾（如 `ul_*` 庫）。
* **[documentation/](documentation/)**: 存放 PDR 簡報、競賽評分表以及系統繪圖檔。
* **[hardware/ground_station/](hardware/ground_station/)**: 存放地面站電路圖。

---

## 文件導覽 (韌體 / 教學 / 歷史)

韌體、教學與專案歷史文件已整理歸檔如下：

* **[教學/教學_6_24.md](教學/教學_6_24.md)**：最新完整版開發教學（三角色架構、板間鏈路與不對稱備援、雙鏈路遙測協定、地面站、主機端測試）。
* **[PROJECT_HISTORY.md](PROJECT_HISTORY.md)**：專案演進史，記錄重大決策與轉折的「為什麼」。
* **[docs/](docs/README.md)**：工程／規劃文件索引（硬體規格表、改進計劃、進度、設計筆記、需求驗證、測試方法）。

> **韌體建置請以頂層 [`Makefile`](Makefile) 為準**：`make`（主航電）、`make build-backup`（備援）、`make build-ground`（地面站）、`make host-test`（純邏輯測試）。
> 工具鏈**必須使用 STM32CubeIDE 內建的 arm-none-eabi gcc**（Makefile 會優先讀取 `local.mk` 自訂路徑，無設定則自動偵測 macOS 預設路徑），**請勿使用 Homebrew 版**。
> 注意：航電專案目錄已更名為 `firmware/main_flight_code`；本文件下方早期撰寫的「VS Code / Homebrew」段落僅供歷史參考，現行建置一律以頂層 `Makefile` 與 `教學/教學_6_24.md` 第 11 節為準。

---

## ⚡ 每日開發流程 (SOP)

為了避免「悲劇」（檔案衝突或覆蓋），每次開工前請牢記口訣：**「先拉，再做，後推」**。

### 1️⃣ 開工第一件事：拉取 (Pull)
**只要你剛坐下準備開始畫圖，請先在 `RocketCom` 資料夾下執行：**
```bash
git pull origin main
```
* **為什麼？** 這能把雲端最新的進度同步到你的電腦。如果不拉就改，上傳時會發生嚴重冲突。

### 2️⃣ 進行開發
* 打開 KiCad，編輯您負責的原理圖或 PCB。
* 記得隨時存檔 (Ctrl+S)。
* **請更新您子專案目錄下的 `備注.md` 以更新開發進度！**

### 3️⃣ 收工上傳三部曲：加、存、推
當您完成一個階段的工作（例如：畫完電源線、擺完去耦電容），請依序執行：

**Step A: 加入變更 (Add)**
```bash
git add .
```

**Step B: 提交紀錄 (Commit)**
寫下您到底改了什麼。！！！絕對不要有啥都沒有描述的空 commit！！！
```bash
git commit -m "清楚的描述，例如：完成主航電板的 3.3V 電源佈線並更新備註"
```

**Step C: 推送到雲端 (Push)**
這一步才會把檔案真正上傳到 GitHub。
```bash
git push origin main
```

---

## 💣 KiCad 協作特別注意事項 (必讀！)

### 1. 關於 PCB 檔案 (`.kicad_pcb`)
Git 很擅長合併程式碼，但**非常不擅長合併二進位/圖形化的 PCB 檔**。
* ⚠️ **黃金法則**：同一時間，**只能有一個人**修改同一張 PCB 板。
* **開發前溝通**：要改 Layout 之前，請在群組喊一聲，確認目前沒人正在編輯再動手。

### 2. 優化後的 `.gitignore` 說明
我們已經全面升級了 `.gitignore`，能自動遞迴忽略以下不必要的檔案：
* KiCad 自動產生的原理圖與 PCB 備份檔 (`*.kicad_sch-bak`, `*.kicad_pcb-bak`)。
* 個人視窗配置檔 (`*.kicad_prl`，避免每個人螢幕大小不同導致衝突)。
* 作業系統垃圾檔（如 macOS 的 `.DS_Store` 與 Windows 的 `Thumbs.db`）。
* 開發快取檔（如 `fp-info-cache`）。
* *請勿強行上傳這些垃圾檔，以保持專案倉庫的輕量與整潔！*

---

## ❓ 常見問題救生圈

### Q1: 我輸入 `git push` 時出現 `error: failed to push some refs...` 怎麼辦？
代表有人在您工作的期間，已經先上傳了新版本。
**解法：**
1. 先輸入 `git pull origin main` (把對方的東西抓下來自動合併)。
2. 如果不幸出現衝突 (Conflict)，請找組長求救。
3. 合併成功後，再輸入一次 `git push origin main`。

### Q2: 為什麼有些備份檔 (`.bak`, `-bak`) 傳不上去？
這是正常的！我們在 `.gitignore` 中設定了過濾，這些是不需要的暫存備份檔。

## 🛠️ 輕量化 STM32 開發與編譯指南 (VS Code / Antigravity IDE)

日常編碼、編譯與燒錄**不需要每次打開重型的 STM32CubeIDE**：在 VS Code / Antigravity IDE 的終端機，直接呼叫**倉庫根目錄的頂層 [`Makefile`](Makefile)**，即可完成主控專案 [firmware/main_flight_code/](firmware/main_flight_code/) 的極速編譯與燒錄。

### 1️⃣ 工具鏈 (Toolchain)：支援使用者自訂本地路徑
本專案**必須使用 STM32CubeIDE 內建的 `arm-none-eabi` gcc 與 `STM32_Programmer_CLI`**，**請勿**用 `brew install` 安裝任何 ARM GCC（例如 `gcc-arm-none-eabi`）——版本不同會造成連結或燒錄問題。

* **本地路徑自訂**：預設使用 macOS 系統路徑。若您在非 macOS 系統（Windows/Linux）或安裝在其他路徑，**請複製 `local.mk.example` 並重新命名為 `local.mk`**，在裡面自訂您的 `CUBEIDE_PLUGINS` 路徑。
* `local.mk` 已經在 `.gitignore` 中設定忽略，不會被提交上傳，保障每位開發者可以使用本機專屬的編譯路徑。
* 頂層 `Makefile` 會自動從 `local.mk`（或預設路徑）載入工具鏈，編譯／燒錄時自動帶入 `PATH`。

> 📌 此為現行唯一正確的工具鏈規範，詳見 [`教學/教學_6_24.md`](教學/教學_6_24.md) 第 11 節與頂層 [`Makefile`](Makefile)。

### 2️⃣ 在 IDE 終端機進行極速編譯 (頂層 Makefile)
**請在倉庫根目錄 `RocketCom/` 下執行**（不要再 `cd` 進子資料夾）。一份程式碼可建置三種角色：

```bash
make               # 編譯主航電 (ROLE_PRIMARY，預設目標)
make build-backup  # 編譯備援航電 (ROLE_BACKUP)
make build-ground  # 編譯地面站   (ROLE_GROUND)
make host-test     # 純邏輯主機端測試（免上板）
make clean         # 清除建置產物
```

編譯成功後，產物在 `firmware/main_flight_code/Debug/` 下（皆已被 `.gitignore` 忽略，不佔倉庫）：
* **`Main_AV_F407.elf`** — 主航電的除錯／燒錄檔（即頂層 `Makefile` 的 `ELF` 變數）
* 連帶產生 `Main_AV_F407.bin`、`Main_AV_F407.list`、`Main_AV_F407.map`
* `Main_AV_F407_backup.elf` / `Main_AV_F407_ground.elf` — 備援／地面站變體（由 `build-backup` / `build-ground` 產生）

### 3️⃣ 一鍵燒錄與序列埠監看
```bash
make flash          # 編譯 + 以 ST-Link SWD 燒錄主航電 .elf
make flash-backup   # 編譯並燒錄備援航電
make flash-ground   # 編譯並燒錄地面站
make monitor        # 開序列埠監看（自動偵測序列埠 @460800；可用 PORT=/dev/cu.xxx 覆寫，Ctrl+A 後按 K 離開）
make all            # 等同 flash + monitor
```

若偏好在 IDE 內單步除錯，可安裝 **Cortex-Debug** 擴充套件，並在 `.vscode/launch.json` 中配置 ST-Link 除錯器，即可按 **F5** 一鍵燒錄與中斷點除錯。

*(註：若你未來在 `.ioc` 中新增或修改了硬體引腳，請打開 `firmware/main_flight_code/Main_AV_F407.ioc` 點擊儲存重新 Generate；其餘日常編碼、編譯與燒錄皆可在本 IDE 終端機以上述 `make` 指令快速完成。)*

---

## 🔧 環境設定檢查

* **KiCad 版本**：請大家統一使用 **KiCad 9.0.7**，避免原理圖或 PCB 檔案格式相容性出錯。
* **Git 個人化設定**：第一次使用請設定您的名字和 Email：
```bash
git config --global user.name "你的名字(英文)"
git config --global user.email "你的Email"
```
彩蛋： 唯一不是AIIIIIIII寫的

## KiCad design hardware/ground_station/GroundStation/GroundStation.kicad_pcb

Parts:
3V3: TestPoint; TestPoint_Pad_2.0x2.0mm
BU101: FanPinHeader_1x03_P2.54mm_Vertical
Buck_5v101: TestPoint; TestPoint_Pad_2.0x2.0mm
C2: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6, C39: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7, C8, C9, C10, C21, C23, C40, C43, C45, C66: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C22, C24: 47u; SMD3528
C26: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C27, C28: 22pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C44: 100u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C46, C102: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C77, C104: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C101: 330u; smd7343
C103: 2.2u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D2: B_3V3; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3: TVS; D_SOD-123
D4: GPS_LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D101: G_5V; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D102, D104: D_Schottky; D_SMA
F1: Fuse; Fuse_1206_3216Metric
FB1: FerriteBead 120R @ 100M; L_2512_6332Metric
GND101: TestPoint; TestPoint_Pad_2.0x2.0mm
H101, H102, H103: MountingHole; MountingHole_3.2mm_M3
J1: SD_Card_Receptacle; SD_Kyocera_145638109511859+
J3: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J4: Conn_Coaxial; U.FL_Hirose_U.FL-R-SMT-1_Vertical
J5: Conn_01x02; Molex_Micro-Fit_3.0_43650-0200_1x02_P3.00mm_Horizontal
J101: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
L101, L102: 1mH; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
P1: USB_C_Plug_USB2.0; USB_C_Receptacle_JAE_DX07S016JA1R1500
Q1: AO3401A; SOT-23
R2_up1, R3, R3_up1, R4, R29, R32, R33: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R16, R17, R26: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R18: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R30, R31: 22ohm; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_Push; SW_PUSH_6mm_H4.3mm
TP1: GPS_BOOT; TestPoint_Pad_D1.0mm
U1: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U9: NEO-M9N-00B; ublox_NEO
U10: E22-400T30S; e22-400t30s_Package
U11: E80-900M23313S; E80-900M2213S
U101: LD1117S33TR_SOT223; SOT-223-3_TabPin2
V_BAT+101: TestPoint; TestPoint_Pad_2.0x2.0mm
Y1: 8Mhz; Crystal_SMD_5032-4Pin_5.0x3.2mm

Connections:
+3.3V: 3V3.1, C2.1, C6.1, C7.1, C8.1, C9.1, C10.1, C21.1, C22.1, C24.1, C39.1, C40.1, C43.1, C44.1, C45.1, C46.1, J1.4 (VDD), J3.1, J101.1, R2_up1.1, R17.2, R29.1, R32.2, R33.2, U1.1 (VBAT), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U9.22 (V_BCKP), U9.23 (VCC), U10.2 (VCC), U11.25 (VCC), U101.2 (VO)
BOOT0: J101.2, R3.1, U1.44 (BOOT0)
BOOT1: R4.1, U1.20 (PB2)
BUCK_5V: BU101.3 (VOUT), Buck_5v101.1, C102.1, D102.2 (A), R16.2
GND: BU101.2 (GND), C2.2, C6.2, C7.2, C8.2, C9.2, C10.2, C21.2, C22.2, C23.2, C24.2, C26.2, C27.2, C28.2, C39.2, C40.2, C43.2, C44.2, C45.2, C46.2, C66.2, C77.2, C102.2, C104.2, D2.1 (K), D3.1 (A1), D4.1 (K), D101.1 (K), GND101.1, J1.3 (VSS), J1.6 (VSS), J1.12 (SHELL1), J1.13 (SHELL2), J3.4, J4.2 (Ext), J5.2, L102.2, P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), P1.S1 (SHIELD), R3.2, R3_up1.2, R4.2, R18.2, SW1.1, U9.10 (GND), U9.12 (GND), U9.13 (GND), U9.24 (GND), U10.1 (GND), U10.12 (GND), U10.13 (GND), U10.14 (GND), U10.23 (GND), U11.1 (GND), U11.8 (GND), U11.19 (GND), U11.26 (GND), U101.1 (GND), Y1.2 (G), Y1.4 (G); also elsewhere on the board
HSE_IN: C27.1, U1.10 (PA0), Y1.1
HSE_OUT: C28.1, U1.11 (PA1), Y1.3
unnamed: BU101.1 (VIN), C104.1, L101.2
unnamed: C101.2, C103.2, L102.1
unnamed: D2.2 (A), R17.1
unnamed: D3.2 (A2), F1.2, Q1.3 (D)
unnamed: D4.2 (A), R26.1
unnamed: D101.2 (A), R16.1
unnamed: C23.1, D102.1 (K), D104.1 (K), U101.3 (VI)
unnamed: J4.1 (In), U9.11 (RF_IN)
unnamed: F1.1, J5.1
unnamed: P1.A5 (CC), R3_up1.1
unnamed: Q1.1 (G), R18.1
unnamed: C66.1, C77.1, FB1.1, U1.9 (VDDA)
unnamed: TP1.1, U9.1 (SAFEBOOT_N)
unnamed: R26.2, U9.3 (TIMEPULSE)
unnamed: R30.1, U10.5 (RXD)
unnamed: R31.1, U10.4 (TXD)
unnamed: R33.1, U11.21 (LR_NRST)
RESET: C26.1, SW1.2, U1.7 (NRST); also elsewhere on the board
SPI1_LoRa2_CS: U1.29 (PA8), U11.6 (NSS)
SPI1_LoRa2_MISO: U1.16 (PA6), U11.3 (MISO)
SPI1_LoRa2_MOSI: U1.17 (PA7), U11.4 (MOSI)
SPI1_LoRa2_SCK: U1.15 (PA5), U11.5 (SCK)
SPI2_SDcard_CS: J1.1 (CD/DAT3), R2_up1.2, U1.21 (PB10)
SPI2_SDcard_MISO: J1.7 (DAT0), U1.27 (PB14)
SPI2_SDcard_MOSI: J1.5 (CLK), U1.26 (PB13)
SPI2_SDcard_SCK: J1.2 (CMD), U1.28 (PB15)
SWCLK: J3.3, U1.37 (PA14)
SWDIO: J3.2, U1.34 (PA13)
USART1_GPS_RESET: R29.2, U1.22 (PB11), U9.8 (RESET_N)
USART1_GPS_RX: U1.31 (PA10), U9.20 (TXD_/_SPI_MISO)
USART1_GPS_TX: U1.30 (PA9), U9.21 (RXD_/_SPI_MOSI)
USART2_LoRa1_AUX: U1.14 (PA4), U10.3 (AUX)
USART2_LoRa1_M0: U1.19 (PB1), U10.7 (M0)
USART2_LoRa1_M1: U1.39 (PB3), U10.6 (M1)
USART2_LoRa1_NRST: R32.1, U1.18 (PB0), U10.22 (RESET)
USART2_LoRa1_RX: R31.2, U1.12 (PA2)
USART2_LoRa1_TX: R30.2, U1.13 (PA3)
USB_5V: D104.2 (A), P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS)
USB_DP_D+: P1.A6 (D+), U1.33 (PA12)
USB_DX_D-: P1.A7 (D-), U1.32 (PA11)
V_BAT+: C101.1, C103.1, L101.1, Q1.2 (S), V_BAT+101.1

Notes on the sheet:
using ipx in the lora model
LORA 433
External reset
boot mode
LORA 920
HSE crystal
Reverse Protection
Buck
decoupling
LDO
maybe a remove before flight?
Test point
Reserved for active atenna
Power
Serial Wire Debug
MCU的TX跟RX
go out
Indicator

Board: 4 copper layers, 82.2 x 108.3 mm, 71 parts (0 on the bottom side), 48 nets.

Other parts of the board:
REST: SW_Push; SW_PUSH_6mm_H4.3mm

Their connections:
GND: REST.1; also elsewhere on the board
RESET: REST.2; also elsewhere on the board

## KiCad design hardware/big_avionic/Second_layer_MCU/Second_layer_MCU.kicad_pcb

Parts:
BZ1: Active Buzzer; MagneticBuzzer_CUI_CMT-8504-100-SMT
C1, C12, C19: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3, C4, C5, C6, C7, C10, C11, C13, C15, C20, C22, C23, C24, C25, C26, C27, C28, C29: 100n; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C8, C9: 2.2u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C14: 1n; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C16: 1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C17, C18: 10pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C21: 4.7u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C30, C31: 22u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1: Y; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: G; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3: W; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D4: 1N4148; D_SOD-123
FB1: FerriteBead 120R @ 100M; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_DIN965_Pad
J1, J6: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J3: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J4: Micro_SD_Card_Det1; microSD_HC_Molex_104031-0811
J5, J8, J10, J11: Conn_01x04; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
J7: Screw_Terminal_01x02; TerminalBlock_Phoenix_PT-1,5-2-3.5-H_1x02_P3.50mm_Horizontal
J9, J13, J14: Conn_01x08; JST_GH_SM08B-GHS-TB_1x08-1MP_P1.25mm_Horizontal
Q2: AO3400A; SOT-23
R1: 100k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R2, R3: 5.1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R4, R5: 4.7k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R6, R7, R8, R9, R17, R19, R32, R33: 22ohm; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R10, R11, R12, R13, R14, R15, R16, R18, R20, R21, R22, R23, R24, R25, R26, R31, R35: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R27: 220; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R28, R29: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R30: 1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
SW1: SW_Push; SW_PUSH_6mm_H4.3mm
SW2, SW3: SW_Push_Shielded; SW_Push_1P1T-SH_NO_CK_KMR2xxG
U1: STM32F405VGTx; LQFP-100_14x14mm_P0.5mm
U2: W25Q128JVS; SOIC-8_5.3x5.3mm_P1.27mm
U3: ADXL375BCCZ; LGA_CC-14-1_ADI-L
U4: BMP388/390; 10LGA_2X2X0p75_BOS-M
U5: BMI088; Bosch_LGA-16_4.5x3mm_P0.5mm_LayoutBorder7x1y_ClockwisePinNu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
Y1: FA-238 16Mhz; Crystal_SMD_SeikoEpson_FA238-4Pin_3.2x2.5mm

Connections:
+3.3V: BZ1.1 (+), C1.1, C2.1, C4.1, C5.1, C6.1, C7.1, C10.1, C11.1, C12.1, C13.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C30.1, C31.1, D4.1 (K), FB1.2, J1.1, J3.1, J4.4 (VDD), J6.3, J11.3, J11.4, R4.2, R5.1, R10.2, R11.2, R13.2, R14.2, R15.2, R20.2, R21.2, R22.2, R23.2, R24.1, R25.2, R26.1, R35.1, U1.6 (VBAT), U1.11 (VDD), U1.19 (VDD), U1.28 (VDD), U1.50 (VDD), U1.75 (VDD), U1.100 (VDD), U2.8 (VCC), U3.1 (VDD_I/O), U3.6 (VS), U4.1 (VDDIO), U4.10 (VDD), U5.3 (VDD), U5.11 (VDDIO)
BOOT0: J3.2, R16.1, U1.94 (BOOT0)
BOOT1: R18.1, U1.37 (PB2)
Battery_Sensing: J10.4, U1.15 (PC0)
Buzzer: R30.2, U1.23 (PA0)
CSB_Accel: R25.1, U1.51 (PB12), U5.14 (~CSB1)
CSB_Baro: R26.2, U1.29 (PA4), U4.6 (CSB)
CSB_Flash: R22.1, U1.77 (PA15), U2.1 (~CS)
CSB_Gyro: R23.1, U1.48 (PB11), U5.5 (~CSB2)
CSB_HIGH_G: R24.2, U1.33 (PC4), U3.7 (*CS)
CSB_LORA920: J14.7, U1.88 (PD7)
FIRE: J5.2, U1.60 (PD13)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, J1.4, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J4.6 (VSS), J4.10 (SHIELD), J5.3, J5.4, J6.4, J7.1, J7.2, J8.3, J9.3, J9.6, J10.1, J10.2, J11.1, J11.2, J13.3, J13.6, J14.1, Q2.2 (S), R1.1, R2.2, R3.2, R16.2, R18.2, R27.1, R28.1, R29.1, R31.2, SW1.1, SW2.1, SW2.SH (B), SW3.1, SW3.SH (B), U1.10 (VSS), U1.20 (VSSA), U1.27 (VSS), U1.74 (VSS), U1.99 (VSS), U2.4 (GND), U3.2 (GND), U3.4 (GND), U3.5 (GND), U4.3 (VSS), U4.8 (VSS)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
HSE_IN: C17.1, U1.12 (PH0), Y1.1
HSE_OUT: C18.1, U1.13 (PH1), Y1.3
I2C1_SCL: J6.1, J9.4, U1.93 (PB7)
I2C1_SDA: J6.2, J9.5, U1.95 (PB8)
INT_Accel1: U1.38 (PE7), U5.16 (INT1)
INT_Accel2: U1.39 (PE8), U5.1 (INT2)
INT_Baro: U1.36 (PB1), U4.7 (INT)
INT_Gyro1: U1.40 (PE9), U5.12 (INT3)
INT_Gyro2: U1.41 (PE10), U5.13 (INT4)
INT_High_G1: U1.35 (PB0), U3.8 (INT1)
INT_High_G2: U1.34 (PC5), U3.9 (INT2)
INT_Magn: J9.2, U1.43 (PE12)
LED_SYS: D1.2 (A), U1.1 (PE2)
LED_State1: D2.2 (A), U1.2 (PE3)
LED_State2: D3.2 (A), U1.3 (PE4)
LORA433_BUSY: J13.2, U1.42 (PE11)
LORA433_M0: J13.8, U1.58 (PD11)
LORA433_M1: J13.7, U1.57 (PD10)
LORA433_RST: J13.1, U1.59 (PD12)
LORA920_BUSY: J14.8, U1.87 (PD6)
LORA920_INT: J14.3, U1.85 (PD4)
LORA920_RST: J14.2, U1.86 (PD5)
unnamed: BZ1.2 (-), D4.2 (A), Q2.3 (D)
unnamed: D1.1 (K), R27.2
unnamed: D2.1 (K), R28.2
unnamed: D3.1 (K), R29.2
unnamed: J2.A5 (CC1), R2.1
unnamed: J2.B5 (CC2), R3.1
unnamed: J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), R1.2, R12.2
unnamed: Q2.1 (G), R30.1, R31.1
unnamed: R32.1, U1.63 (PC6)
unnamed: R6.1, U1.65 (PC8)
unnamed: R7.1, U1.66 (PC9)
unnamed: R8.1, U1.78 (PC10)
unnamed: R9.1, U1.79 (PC11)
unnamed: R19.1, U1.80 (PC12)
unnamed: R33.2, U1.83 (PD2)
unnamed: R17.1, U1.55 (PD8)
unnamed: C8.1, U1.49 (VCAP_1)
unnamed: C9.1, U1.73 (VCAP_2)
unnamed: R20.1, U2.7 (~HOLD/~RESET/IO_{3})
unnamed: R21.1, U2.3 (~WP/IO_{2})
PWM Servo: J5.1, U1.61 (PD14)
RESET: C3.1, J8.4, R35.2, SW1.2, U1.14 (NRST)
RST_GPS: J9.1, U1.67 (PA8)
SDIO_CK: J4.5 (CLK), R19.2
SDIO_CMD: J4.3 (CMD), R11.1, R33.1
SDIO_D0: J4.7 (DAT0), R6.2, R10.1
SDIO_D1: J4.8 (DAT1), R7.2, R14.1
SDIO_D2: J4.1 (DAT2), R8.2, R15.1
SDIO_D3: J4.2 (DAT3/CD), R9.2, R13.1
SDIO_DET: J4.9 (DET), U1.84 (PD3)
SPI1_MISO: U1.31 (PA6), U3.12 (SDO/ALT_ADDRESS), U4.5 (SDO)
SPI1_MOSI: U1.32 (PA7), U3.13 (SDA/SDI/SDIO), U4.4 (SDI)
SPI1_SCK: U1.30 (PA5), U3.14 (SCL/SCLK), U4.2 (SCK)
SPI2_MISO: U1.53 (PB14), U5.10 (SDO2), U5.15 (SDO1)
SPI2_MOSI: U1.54 (PB15), U5.9 (SDI/SDA)
SPI2_SCK: U1.52 (PB13), U5.8 (SCK/SCL)
SPI3_MISO: J14.4, U1.90 (PB4), U2.2 (DO/IO_{1})
SPI3_MOSI: J14.5, U1.91 (PB5), U2.5 (DI/IO_{0})
SPI3_SCK: J14.6, U1.89 (PB3), U2.6 (CLK)
SUP_STAT: J10.3, U1.16 (PC1)
SWCLK: J1.3, U1.76 (PA14)
SWDIO: J1.2, U1.72 (PA13)
UART3_RX: J13.4, U1.56 (PD9)
UART3_TX: J13.5, R17.2
UART6_RX: J9.7, U1.64 (PC7)
UART6_TX: J9.8, R32.2
USART2_RX: J8.1, U1.26 (PA3)
USART2_TX: J8.2, U1.25 (PA2)
USB_D+: J2.A6 (D+), J2.B6 (D+), U1.71 (PA12)
USB_D-: J2.A7 (D-), J2.B7 (D-), U1.70 (PA11)
USB_VBUS: R12.1, U1.68 (PA9)
USER_BT1: C28.1, R4.1, SW2.2, U1.24 (PA1)
USER_BT2: C29.1, R5.2, SW3.2, U1.18 (PC3)
VREF: C14.1, C15.1, C16.1, FB1.1, U1.21 (VREF+), U1.22 (VDDA)

Notes on the sheet:
Connection to power layer
High g accel meter
HSE crystal
Ignition connector
Connection to top layer
SD card
boot mode
Mounting hole
Reserved connector
decoupling
External reset
Flash
UART communication
ESR<2ohm
22ohm near mcu to prevent from ringing
MCU
Connection to lora layer
Connection to backup_AV
Barometer
common ground to Backup_AV GND
Indicator
Buttom
USB
IMU
decoupling for VDD,VDDIO
Serial Wire Debug

Board: 4 copper layers, 68.0 x 68.0 mm, 98 parts (24 on the bottom side), 89 nets.
