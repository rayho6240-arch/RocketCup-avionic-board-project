# Repository rayho6240-arch/RocketCup-avionic-board-project

## KiCad design BigAvionic/lora/lora.kicad_pcb

Board: 4 copper layers, 68.0 x 68.0 mm, 24 parts (5 on the bottom side), 17 nets.

Parts:
3V3: TestPoint; TestPoint_Pad_D1.0mm
C1, C3, C4, C6: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 100u; CP_EIA-7343-31_Kemet-D_HandSolder
C5: 22u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C7: 470u; CP_EIA-7343-43_Kemet-X_HandSolder
D1: RED_LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: TVS; D_SMA
GND1: TestPoint; TestPoint_Pad_D1.0mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_DIN965_Pad
J1: Conn_01x04; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
J2, J3: Conn_01x08; JST_GH_SM08B-GHS-TB_1x08-1MP_P1.25mm_Horizontal
R1: 22ohm; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: E22-400T30S; XCVR_E22-900T30S
U2: E80-900M23313S; E80-xxxM2213S

Connections:
+3.3V: 3V3.1, C1.1, C2.1, C4.1, C5.1, C7.2, D2.2 (A2), J1.3, J1.4, R2.2, R3.2, R4.2, U1.2 (VCC), U2.25 (VCC)
CSB_LORA920: J3.2, U2.6 (NSS)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, D1.1 (K), D2.1 (A1), GND1.1, J1.1, J1.2, J2.3, J2.6, J3.8, U1.1 (GND), U1.12 (GND), U1.13 (GND), U1.14 (GND), U1.23 (GND), U2.1 (GND), U2.8 (GND), U2.19 (GND), U2.26 (GND)
LORA433_BUSY: J2.7, U1.3 (AUX)
LORA433_M0: J2.1, U1.7 (M0)
LORA433_M1: J2.2, U1.6 (M1)
LORA433_RST: C3.1, J2.8, R2.1, U1.22 (RESET)
LORA920_BUSY: J3.1, U2.7 (BUSY)
LORA920_INT: J3.6, U2.22 (DIO9)
LORA920_RST: C6.1, J3.7, R3.1, U2.21 (LR_NRST)
unnamed: D1.2 (A), R4.1
unnamed: R1.1, U1.4 (TXD)
SPI3_MISO: J3.5, U2.3 (MISO)
SPI3_MOSI: J3.4, U2.4 (MOSI)
SPI3_SCK: J3.3, U2.5 (SCK)
UART3_RX: J2.5, R1.2
UART3_TX: J2.4, U1.5 (RXD)

## KiCad design BigAvionic/power layer_new/power layer.kicad_pcb

Board: 4 copper layers, 68.0 x 68.0 mm, 57 parts (0 on the bottom side), 20 nets.

Parts:
3V3_1, 3V3_LORA1, 5V1: TestPoint; TestPoint_Pad_D1.0mm
BU1: R-78K5.0-2.0L; CONV_R-78K5.0-2.0L
BU2: R-78K3.3-2.0L; CONV_R-78K5.0-2.0L
Buck_5v1: TestPoint; TestPoint_Pad_D1.0mm
C1: 10u; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C2, C3, C5, C6, C11, C12: 22u; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C4, C7, C10, C14, C15: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8, C9, C13: 47u; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C_Damping1, C_Damping2: 22u; CP_EIA-3528-21_Kemet-B_HandSolder
D1: TVS; D_SMA
D2: SS24; D_SMA
D3: G_5V; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D4, D5: G_3V3; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
GND1: TestPoint; TestPoint_Pad_D1.0mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_DIN965_Pad
J1: Conn_01x02; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J3, J4, J5, J6: Conn_01x04; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
L1, L2: 4.7uH; L_APV_ANR4020
Q1, Q2: AO3401A; SOT-23
R1, R2: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 1M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4: 470k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5: 330; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6, R11: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R8: 5k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9, R10: 5.1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: LD1117S33TR_SOT223; SOT-223-3_TabPin2
U2: LTC4412xS6; TSOT-23-6
V_BAT+1: TestPoint; TestPoint_Pad_D1.0mm

Connections:
5V: 5V1.1, C1.1, C3.1, C4.1, C13.2, D2.1 (K), L2.1, Q2.2 (S), R5.2, U1.3 (VI), U2.6 (SENSE)
+3.3V: 3V3_1.1, C7.1, C8.1, C9.1, J4.1, J4.2, J5.1, J5.2, R4.1, R6.2, U1.2 (VO)
+3.3V_LoRa: 3V3_LORA1.1, BU2.3 (VOUT), C12.1, C15.1, J6.1, J6.2, R11.2
+USB_5V: D2.2 (A), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), R2.2
BUCK_5V: BU1.3 (VOUT), Buck_5v1.1, C10.2, C11.1, Q2.3 (D), U2.1 (VIN)
Battery_Sensing: C14.1, J3.1, R7.1, R8.2
GND: BU1.2 (GND), BU2.2 (GND), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.1, C11.2, C12.2, C13.1, C14.2, C15.2, C_Damping1.2, C_Damping2.2, D1.1 (A1), D3.1 (K), D4.1 (K), D5.1 (K), GND1.1, J1.2, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J3.3, J3.4, J4.3, J4.4, J5.3, J5.4, J6.3, J6.4, R1.2, R3.2, R8.1, R9.2, R10.2, U1.1 (GND), U2.2 (GND)
unnamed: BU1.1 (VIN), C5.1, C_Damping2.1, L1.2
unnamed: BU2.1 (VIN), C6.1, C_Damping1.1, L2.2
unnamed: D1.2 (A2), J1.1, Q1.3 (D)
unnamed: D3.2 (A), R5.1
unnamed: D4.2 (A), R6.1
unnamed: D5.2 (A), R11.1
unnamed: J2.A5 (CC1), R9.1
unnamed: J2.B5 (CC2), R10.1
unnamed: Q1.1 (G), R1.1
unnamed: Q2.1 (G), U2.5 (GATE)
unnamed: R2.1, R3.1, U2.3 (CTL)
SUP_STAT: J3.2, R4.2, U2.4 (STAT)
V_BAT+: C2.1, L1.1, Q1.2 (S), R7.2, V_BAT+1.1

## KiCad design GroundStation/GroundStation/GroundStation.kicad_pcb

Parts:
3V3: TestPoint; TestPoint_Pad_2.0x2.0mm
Buck_5v101: TestPoint; TestPoint_Pad_2.0x2.0mm
C2: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6, C39: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7, C8, C9, C10, C12, C21, C23, C40, C43, C45, C66: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C13, C14, C15: 4.7u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C16: 10p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C17, C18, C19, C22, C24: 47u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C41: NC; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C42: 100p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C44: 100u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C46: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C77: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D2: B_3V3; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3, D102, D103: TVS; D_SOD-123
D4: GPS_LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D101: G_5V; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
F1: Fuse; Fuse_1206_3216Metric
FB1: FerriteBead 120R @ 100M; L_2512_6332Metric
GND101: TestPoint; TestPoint_Pad_2.0x2.0mm
J1: SD_Card_Receptacle; SD_Kyocera_145638109511859+
J4: Conn_Coaxial; BNC_Amphenol_B6252HB-NPP3G-50_Horizontal
J5: Conn_01x02; PinHeader_1x02_P2.54mm_Horizontal
L1: 6.8u; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
L2: short; L_Bourns_SDR0604
P1: USB_C_Plug_USB2.0; USB3_A_Molex_48393-001
Q1: TSM3481CX6 RFG; SOT-23
R1: 390k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R16(PG_pull_up)101, R18: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2_up1, R3_up1, R29, R32, R33: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R13: 18k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R14: 220k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15: 30k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R16, R17, R26: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R27: NC; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R30, R31: 22ohm; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP1: GPS_BOOT; TestPoint_Pad_D1.0mm
U1: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U4: TPS54538RQFR
U9: NEO-M9N-00B; ublox_NEO
U10: E22-400T30S; e22-400t30s_Package
U11: E80-900M23313S; E80-900M2213S
U101: LD1117S33TR_SOT223; SOT-223-3_TabPin2
V_BAT+101: TestPoint; TestPoint_Pad_2.0x2.0mm

Connections:
3.3V: C2.1, C6.1, C7.1, C8.1, C9.1, C10.1, C39.1, C40.1, FB1.2, J1.4 (VDD), R2_up1.1, R29.1, U1.1 (VBAT), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U9.22 (V_BCKP), U9.23 (VCC)
+3.3V: 3V3.1, C21.1, C22.1, C24.1, C43.1, C44.1, C45.1, C46.1, R17.2, R32.2, R33.2, U10.2 (VCC), U11.25 (VCC), U101.2 (VO)
BUCK_5V: Buck_5v101.1, C16.1, C17.1, C18.1, C19.1, D103.2 (A2), L1.1, R14.1, R16.2, R16(PG_pull_up)101.1
GND: C2.2, C6.2, C7.2, C8.2, C9.2, C10.2, C12.2, C13.2, C14.2, C15.2, C17.2, C18.2, C19.2, C21.2, C22.2, C23.2, C24.2, C39.2, C40.2, C41.2, C43.2, C44.2, C45.2, C46.2, C66.2, C77.2, D2.1 (K), D3.1 (A1), D4.1 (K), D101.1 (K), GND101.1, J1.3 (VSS), J1.6 (VSS), J1.12 (SHELL1), J1.13 (SHELL2), J4.2 (Ext), J5.2, P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), P1.S1 (SHIELD), R2.1, R3_up1.2, R13.2, R15.2, R18.2, U4.4 (GND), U9.10 (GND), U9.12 (GND), U9.13 (GND), U9.24 (GND), U10.1 (GND), U10.12 (GND), U10.13 (GND), U10.14 (GND), U10.23 (GND), U11.1 (GND), U11.8 (GND), U11.19 (GND), U11.26 (GND), U101.1 (GND)
unnamed: C41.1, C42.1, L2.2, R27.1
unnamed: D2.2 (A), R17.1
unnamed: D3.2 (A2), F1.2, Q1.3 (D)
unnamed: D4.2 (A), R26.1
unnamed: D101.2 (A), R16.1
unnamed: C23.1, D102.1 (A1), D103.1 (A1), U101.3 (VI)
unnamed: J4.1 (In), L2.1
unnamed: F1.1, J5.1
unnamed: P1.A5 (CC), R3_up1.1
unnamed: Q1.1 (G), R18.1
unnamed: C66.1, C77.1, FB1.1, U1.9 (VDDA)
unnamed: R1.1, R2.2, U4.2 (EN)
unnamed: C16.2, R14.2, R15.1, U4.3 (FB)
unnamed: R13.1, U4.7 (MODE)
unnamed: L1.2, U4.8 (SW)
unnamed: C42.2, U9.11 (RF_IN)
unnamed: TP1.1, U9.1 (SAFEBOOT_N)
unnamed: R26.2, U9.3 (TIMEPULSE)
unnamed: R27.2, U9.9 (VCC_RF)
unnamed: R30.1, U10.5 (RXD)
unnamed: R31.1, U10.4 (TXD)
unnamed: R33.1, U11.21 (LR_NRST)
PG_BUCK: R16(PG_pull_up)101.2, U4.9 (SS/PG)
SPI1_LoRa2_CS: U1.29 (PA8), U11.6 (NSS)
SPI1_LoRa2_MISO: U1.16 (PA6), U11.3 (MISO)
SPI1_LoRa2_MOSI: U1.17 (PA7), U11.4 (MOSI)
SPI1_LoRa2_SCK: U1.15 (PA5), U11.5 (SCK)
SPI2_SDcard_CS: J1.1 (CD/DAT3), R2_up1.2, U1.21 (PB10)
SPI2_SDcard_MISO: J1.7 (DAT0), U1.27 (PB14)
SPI2_SDcard_MOSI: J1.5 (CLK), U1.26 (PB13)
SPI2_SDcard_SCK: J1.2 (CMD), U1.28 (PB15)
USART1_GPS_RESET: R29.2, U1.22 (PB11), U9.8 (RESET_N)
USART1_GPS_RX: U1.31 (PA10), U9.20 (TXD_/_SPI_MISO)
USART1_GPS_TX: U1.30 (PA9), U9.21 (RXD_/_SPI_MOSI)
USART2_LoRa1_AUX: U1.14 (PA4), U10.3 (AUX)
USART2_LoRa1_M0: U1.19 (PB1), U10.7 (M0)
USART2_LoRa1_M1: U1.20 (PB2), U10.6 (M1)
USART2_LoRa1_NRST: R32.1, U1.18 (PB0), U10.22 (RESET)
USART2_LoRa1_RX: R31.2, U1.12 (PA2)
USART2_LoRa1_TX: R30.2, U1.13 (PA3)
USB_5V: D102.2 (A2), P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS)
USB_DP_D+: P1.A6 (D+), U1.33 (PA12)
USB_DX_D-: P1.A7 (D-), U1.32 (PA11)
V_BAT+: C12.1, C13.1, C14.1, C15.1, Q1.2 (S), R1.2, U4.5 (VIN), U4.6 (VIN), V_BAT+101.1

Notes on the sheet:
using ipx in the lora model
LORA 433
LORA 920
Reverse Protection
Buck
decoupling
LDO
maybe a remove before flight?
Test point
Reserved for active atenna
Power
MCU的TX跟RX
Indicator

Board: 4 copper layers, 83.0 x 108.3 mm, 72 parts (0 on the bottom side), 48 nets.
